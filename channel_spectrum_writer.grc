options:
  parameters:
    generate_options: hb
    id: channel_spectrum_writer
    output_language: python
    title: Channel Spectrum Writer
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: frame_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ts_dict
  id: variable
  parameters:
    value: pmt.dict_add(pmt.make_dict(), pmt.intern("ts_start"), pmt.from_double(datetime.now().timestamp()))
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: ts_dict
    file: file_dir + "fft_captures_"  + str(datetime.now().strftime("%y-%m-%d_%H-%M-%S")) + "_" + str(channel_freq/1e6) + "MHz.bin"
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: frame_rate
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_share_0_0
  id: blocks_tag_share
  parameters:
    io_type: float
    share_type: float
  states: {}
- name: blocks_tags_strobe_0_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("tag_strobe")
    nsamps: fft_size
    type: float
    value: pmt.intern("tag_strobe")
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency
    type: eng_float
    value: '0'
  states: {}
- name: channel_freq
  id: parameter
  parameters:
    label: Channel Frequency
    type: eng_float
    value: '0'
  states: {}
- name: cutoff_freq
  id: parameter
  parameters:
    label: Cutoff Freq
    type: eng_float
    value: '0'
  states: {}
- name: file_dir
  id: parameter
  parameters:
    label: File Dir
    type: str
    value: '""'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: input_decimation
  id: parameter
  parameters:
    label: Innput Decimation
    type: eng_float
    value: '1'
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: frame_rate
    ref_scale: '2'
    sample_rate: samp_rate / input_decimation
    shift: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: input_decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '0'
  states: {}
- name: transition_width
  id: parameter
  parameters:
    label: Transition Width
    type: eng_float
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_tag_share_0_0, '0', blocks_file_meta_sink_0_0, '0']
- [blocks_tags_strobe_0_0, '0', blocks_tag_share_0_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_tag_share_0_0, '0']
- [logpwrfft_x_0, '0', blocks_vector_to_stream_0, '0']
- [low_pass_filter_0_0, '0', logpwrfft_x_0, '0']
- [low_pass_filter_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
