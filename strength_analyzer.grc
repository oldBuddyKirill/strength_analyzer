options:
  parameters:
    generate_options: qt_gui
    id: strength_analyzer
    output_language: python
    title: Strength Analizer
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '62'
    value: '30'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 80e6
    step: 0.1e6
    stop: 120e6
    value: 91e6
  states: {}
- name: channel_1
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: channel_10
  id: variable
  parameters:
    value: 94.1e6
  states: {}
- name: channel_11
  id: variable
  parameters:
    value: 95e6
  states: {}
- name: channel_12
  id: variable
  parameters:
    value: 95.5e6
  states: {}
- name: channel_2
  id: variable
  parameters:
    value: 88e6
  states: {}
- name: channel_3
  id: variable
  parameters:
    value: 88.4e6
  states: {}
- name: channel_4
  id: variable
  parameters:
    value: 89.3e6
  states: {}
- name: channel_5
  id: variable
  parameters:
    value: 89.7e6
  states: {}
- name: channel_6
  id: variable
  parameters:
    value: 90.1e6
  states: {}
- name: channel_7
  id: variable
  parameters:
    value: 90.6e6
  states: {}
- name: channel_8
  id: variable
  parameters:
    value: 92.9e6
  states: {}
- name: channel_9
  id: variable
  parameters:
    value: 93.3e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: data_dir
  id: variable
  parameters:
    value: '"data/"'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: input_decimation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: main_sample_rate
  id: variable
  parameters:
    value: samp_rate / input_decimation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channel_spectrum_writer_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_1
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_2
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_0_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_8
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_1
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_3
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_1_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_9
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_2
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_4
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_2_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_10
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_3
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_5
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_3_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_11
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_4
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_6
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_4_0
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_12
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: channel_spectrum_writer_0_5
  id: channel_spectrum_writer
  parameters:
    center_freq: center_freq
    channel_freq: channel_7
    cutoff_freq: cutoff_freq
    file_dir: data_dir
    input_decimation: input_decimation
    samp_rate: samp_rate
    transition_width: transition_width
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: bb_gain
    freq0: center_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"Spectrum analizer"'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_throttle2_2, '0', channel_spectrum_writer_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_0_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_1, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_1_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_2, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_2_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_3, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_3_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_4, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_4_0, '0']
- [blocks_throttle2_2, '0', channel_spectrum_writer_0_5, '0']
- [blocks_throttle2_2, '0', qtgui_sink_x_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_throttle2_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
